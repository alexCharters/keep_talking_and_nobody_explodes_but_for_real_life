MOVIW 0xC000, r1
MOVIW 0xE800, r2
MOVIW 0xEC00, r3
MOVIW 2, r4
MOVIW 120, r5
MOVIW 2, r6
STOR r4, r1
STOR r6, r3
STOR r5, r2
MOVIW 0xC200, r1
MOVIW 0xC400, r2
MOVIW 0xCC00, r3
MOVIW 0xFF00, r4
MOVIW 0x000F, r5
MOVIW 0x0003, r6
STOR r4, r1
STOR r5, r2
STOR r6, r3



MOVIW 0xD400, r2
MOVIW 1, r7
STOR r7, r2

MOVIW 0xFFFF, r7
BUSYWAIT: OR r0, r0
SUBI 1, r7
CMP r7, r0
JNE BUSYWAIT

MOVIW 0xFFFF, r7
BUSYWAIT2: OR r0, r0
SUBI 1, r7
CMP r7, r0
JNE BUSYWAIT2

MOVIW 0xFFFF, r7
BUSYWAIT3: OR r0, r0
SUBI 1, r7
CMP r7, r0
JNE BUSYWAIT3

MOVIW 0xFFFF, r7
BUSYWAIT4: OR r0, r0
SUBI 1, r7
CMP r7, r0
JNE BUSYWAIT4

MOVIW 0xAAAA, r7
BUSYWAIT5: OR r0, r0
SUBI 1, r7
CMP r7, r0
JNE BUSYWAIT5


MOVIW 0xCD00, r3
MOVIW 2, r4
STOR r4, r3

EXIT: OR r0, r0
JUC EXIT